FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://system-ori.dtsi"
