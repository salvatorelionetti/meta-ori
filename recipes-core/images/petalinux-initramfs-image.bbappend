#INITRAMFS_SCRIPTS_append = " initramfs-framework-nbdrootfs "
